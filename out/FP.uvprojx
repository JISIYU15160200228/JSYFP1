# Keil uVision project FP.uvprojx, settings and files
target Final Project (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: LPC1114FBD48/301 NXP
  pack: Keil.LPC1100_DFP.1.4.0
  cpu: IRAM(0x10000000,0x2000) IROM(0x00000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: FP
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x2000
  group User Code
    ../src/: main.c
  group Driver Code
    ../src/: ADC.c UART.c KEY.c PWM.c INIT.c I2C.c GPIO.c UI.c LCD1602.c
software components: CMSIS:CORE 5.0.0, Device:Startup 1.0.0
